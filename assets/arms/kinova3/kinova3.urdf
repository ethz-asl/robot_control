Commit message: minor changes

File: assets/arms/kinova3/kinova3.urdf (robot description, URDF)
Before this commit: robot kinova3, 10 links, 9 joints
Joints:
- joint joint_7: limit lower=-3.14 upper=3.14 effort=9 velocity=1.2218 -> lower=-23.14 upper=23.14 effort=9 velocity=1.2218
